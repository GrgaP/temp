<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\dims_kl3333.ewp</path>
  </project>
  <batchBuild />
</workspace>
