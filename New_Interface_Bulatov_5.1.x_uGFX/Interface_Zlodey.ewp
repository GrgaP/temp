# IAR project Interface_Zlodey.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746ZG ST STM32F746ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F746xx; USE_STM32F429I_DISCO
  ICCARM.CCIncludePath2: ; Src; Include\; gui\; gui\rsc; ugfx\; ugfx\drivers\gdisp\framebuffer_dma2d\; ugfx\drivers\ginput\toggle\Pal\; ugfx\drivers\ginput\touch\STMPE811\; board\; ugfx_fonts\; lib\extra\ex_types\; bsp_v510_src\STM32F7xx_HAL_Driver\Inc\; bsp_v510_src\STM32F7xx_HAL_Driver\src\; bsp_v510_src\USART_DMA_DRV\; bsp_v510_src\I2C_DRV\; bsp_v510_src\SHT20_drv\; bsp_v510_src\LCD_CFG\; bsp_v510_src\ILI9341_DRV\; bsp_v510_src\LTDC_DRV\; bsp_v510_src\CMSIS\device; bsp_v510_src\CMSIS\device\include\; bsp_v510_src\CMSIS\core\include\; bsp_v510_src\; bsp_v510_src\DIMS_RTC; common_dims_src\; USB_CLI_CDC_comps\; Middlewares\ST\STM32_USB_Device_Library\Core\Inc; Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc; Middlewares\Third_Party\FreeRTOS\Source\include\; Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM7\r0p1; Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; Middlewares\Third_Party\FreeRTOS-Plus\FreeRTOS-Plus-CLI
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: Include; board\
  OBJCOPY.OOCOutputFile: DIMS_DSP_V5.1.x.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: settings\stm32f746xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F429ZI ST STM32F429ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: STM32F4xx_DSP_StdPeriph_Lib_V1.2.0\Libraries\CMSIS\Device\ST\STM32F4xx\Include; STM32F4xx_DSP_StdPeriph_Lib_V1.2.0\Libraries\CMSIS\Include; STM32F4xx_DSP_StdPeriph_Lib_V1.2.0\Libraries\STM32F4xx_StdPeriph_Driver\inc; STM32F4xx_DSP_StdPeriph_Lib_V1.2.0\Libraries\STM32F4xx_StdPeriph_Driver\src
  ICCARM.CCOptLevel: 0
  OBJCOPY.OOCOutputFile: hello_world.hex
  ILINK.IlinkIcfFile: stm32f429xI.icf
  group (top)
    ./: main.c
  group BSP_SRC
    bsp_v510_src/: adc_battery.c backlight.c buzzer_pwm.c delay.c flash_memory.c gpio_mco.c keyboard_tmr.c leds.c power.c task_manager.c
  group BSP_SRC/I2C_DRV
    bsp_v510_src/I2C_DRV/: i2c_drv.c
  group BSP_SRC/ILI9341_DRV
    bsp_v510_src/ILI9341_DRV/: ili9341_drv.c
  group BSP_SRC/LTDC_DRV
    bsp_v510_src/LTDC_DRV/: ltdc_drv.c
  group BSP_SRC/RTC
    bsp_v510_src/DIMS_RTC/: dims_rtc.c
  group BSP_SRC/RTC/SDRAM_DRV
    bsp_v510_src/: dims_dsp_sdram.c dims_dsp_sdram.h
  group BSP_SRC/SHT20_drv
    bsp_v510_src/SHT20_drv/: sht20_module.c
  group BSP_SRC/UART_DRV
    bsp_v510_src/USART_DMA_DRV/: dma_usart_f7_hal.c
  group Common_SRC
    common_dims_src/: binary_iar.h bug.c bug_spectra.c convert.c crc_16.c crc_16.h DIMS_SystemSettings.h disorber.c graph.c logotype.c menu.c menu_calibration.c rgb.c SpectrumMath.c
  group Common_SRC/SpectraBug
    common_dims_src/: spectra_bug.c spectra_bug.h spectra_data.c spectra_data.h
  group GUI/Board
    board/: board_framebuffer.h gfxconf.h ginput_lld_toggle_board.h gmouse_lld_MCU_board.h gmouse_lld_STMPE811_board.h test.c
  group GUI/Fonts
    ugfx_fonts/: userfonts.h
  group GUI/uGFX
    ugfx/drivers/gdisp/framebuffer_dma2d/: gdisp_lld_framebuffer.c
    ugfx/src/: gfx_mk.c
    ugfx/drivers/ginput/toggle/Pal/: ginput_lld_toggle_Pal.c
    ugfx/drivers/ginput/touch/STMPE811/: gmouse_lld_STMPE811.c
  group GUI/virt_num_keyboard
    board/: passw_text_edit.c passw_text_edit.h security.c virt_num_keyboard.c virt_num_keyboard.h
  group GUI/VirtKeyb
    gui/: gui.c gui.h romfs_files.h user_colors.h user_styles.h
  group lib/extra
    lib/extra/ex_types/: ex_types.h
  group Libraries/CMSIS
    bsp_v510_src/CMSIS/device/: startup_stm32f746xx.s system_stm32f7xx.c
  group Libraries/StdPeriph
    bsp_v510_src/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cec.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_eth.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_irda.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_lptim.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_msp_template.c stm32f7xx_hal_nand.c stm32f7xx_hal_nor.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_smartcard.c stm32f7xx_hal_smartcard_ex.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c stm32f7xx_ll_fmc.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_usb.c
  group Middlewares/FreeRTOS
    Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1/: port.c portasm.s
  group Middlewares/FreeRTOS/CFG
    board/: FreeRTOSConfig.h
  group Middlewares/USB_Device_Lib
    Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Middlewares/USB_Device_Lib/CFG
    USB_CLI_CDC_comps/: usbd_conf.c usbd_conf.h
