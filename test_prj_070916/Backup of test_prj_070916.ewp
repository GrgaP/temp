# IAR project Backup of test_prj_070916.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746NG ST STM32F746NG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: STM32F746xx; USE_HAL_DRIVER; USE_STM32746G_DISCOVERY
  ICCARM.CCIncludePath2: Inc; CMSIS\Device\Include; CMSIS\Core\Include; Drivers\HAL\Inc; Drivers\HW\Common; Drivers\HW\DISCO; Drivers\HW\DISCO\Components; Drivers\HW\LTDC_DRV; Middlewares\FreeRTOS\portable; Middlewares\FreeRTOS\CMSIS_RTOS; Middlewares\FreeRTOS\include; Config\FreeRTOS; Config\uGFX\; Add; Add\Fonts; Src\rtc_module; Src\gui; Src\gui\rsc; Middlewares\ugfx\; Middlewares\ugfx_fonts\; Middlewares\ugfx\src\; Middlewares\ugfx\drivers\gdisp\framebuffer_dma2d; Middlewares\ugfx\drivers\ginput\touch\FT5336\; STM32F746-Discovery\; D:\Work\devel\test_prj_210416\SpectraData\Clear
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: Config\FreeRTOS
  OBJCOPY.OOCOutputFile: test_prj_300816.srec
  ILINK.IlinkOutputFile: test_prj_210416.out
  ILINK.IlinkIcfFile: stm32f746xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application
    src/rtc_module/: dims_rtc.c
    src/: main.c stm32f7xx_hal_msp.c stm32f7xx_it.c
  group Application/EVARM
    CMSIS/device/: startup_stm32f746xx.s
  group Application/gui
    src/gui/: gui.c
  group Drivers/CMSIS
    CMSIS/device/: system_stm32f7xx.c
  group Drivers/HAL
    Drivers/HAL/Src/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cec.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_eth.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_irda.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_lptim.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_nand.c stm32f7xx_hal_nor.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_smartcard.c stm32f7xx_hal_smartcard_ex.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c stm32f7xx_ll_fmc.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_usb.c
  group Drivers/HW Drivers
    STM32F746-Discovery/: gmouse_lld_FT5336_board.h stm32f7_i2c.c
    Drivers/HW/LTDC_DRV/: ltdc_drv.c
  group Drivers/HW Drivers/DISCO
    Drivers/HW/DISCO/: stm32746g_discovery.c stm32746g_discovery_sdram.c
  group Middlewares/FreeRTOS
    Middlewares/FreeRTOS/CMSIS_RTOS/: cmsis_os.c
    Middlewares/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    Middlewares/FreeRTOS/MemMang/: heap_4.c
    Middlewares/FreeRTOS/portable/: port.c portasm.s
  group Middlewares/FreeRTOS/cfg
    Config/FreeRTOS/: FreeRTOSConfig.h
  group Middlewares/GUI
    Middlewares/ugfx/drivers/gdisp/framebuffer_dma2d/: gdisp_lld_framebuffer.c
    Middlewares/ugfx/src/: gfx_mk.c
    Middlewares/ugfx/drivers/ginput/touch/FT5336/: gmouse_lld_FT5336.c
  group Middlewares/GUI/cfg
    Config/uGFX/: board_framebuffer.h gfxconf.h
